# Keil uVision project UART_Mater.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: User_master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\main;..\library;..\user_master
  link misc: removeunused
  group Main
    ./: main.c
  group Library
    ../library/: WS2812B_RGB_Driver.c STC8_TIMER2_UART.c CircularQueue.c TransmissionCommuicationProtcol.c CircularQueueStruct.c
